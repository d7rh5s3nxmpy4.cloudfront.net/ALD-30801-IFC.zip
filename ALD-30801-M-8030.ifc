Properties of the parts of a building model (IFC2X3)

# File
Description: ViewDefinition [CoordinationView]
Time: 2025-10-28T08:31:56
Written by: Processor version 6.0.0.0
Made in: Xbim.IO.MemoryModel

# IfcDistributionPort (2)
Name | FlowDirection
 | SOURCE
 | SINK

# IfcFlowTerminal: ALD-30801-M-8030
Type - Description: Default Lamp Description; PredefinedType: FLUORESCENT
Photometric Information - Lamp names: ALD-30801-M-8030; Light output ratio: 1; Luminous flux: 1993.97 lm
Pset_LampTypeCommon - ContributedLuminousFlux: 1993.97 lm; LightEmitterNominalPower: 16.7 W; Spectrum: 380: 14457, 385: 1398, 390: 13343, 395: 13418, 400: 12377, 405: 12603, 410: 13259, 415: 14275, 420: 17999, 425: 25391, 430: 39557, 435: 658, 440: 13349, 445: 25524, 450: 464, 455: 570347, 460: 530277, 465: 429981, 470: 378694, 475: 328763, 480: 303691, 485: 30493, 490: 339037, 495: 355858, 500: 4025603, 505: 441992, 510: 472424, 515: 49952, 520: 538222, 525: 550136, 530: 574753, 535: 598184, 540: 617614, 545: 641598, 550: 66056, 555: 684892, 560: 710677, 565: 733965, 570: 764085, 575: 799925, 580: 834333, 585: 877809, 590: 892608, 595: 91929, 600: 945643, 605: 967977, 610: 985902, 615: 995899, 620: 999054, 625: 994851, 630: 97972, 635: 959837, 640: 931403, 645: 892768, 650: 845429, 655: 793465, 660: 736654, 665: 678382, 670: 620572, 675: 564233, 680: 511019, 685: 461161, 690: 414114, 695: 362145, 700: 321011, 705: 283907, 710: 245611, 715: 217071, 720: 19102, 725: 167794, 730: 144638, 735: 123196, 740: 108502, 745: 97499, 750: 88019, 755: 81951, 760: 73415, 765: 76564, 770: 68426, 775: 66586, 780: 0; ColorTemperature: 3000 K; ColorRenderingIndex: 80

# IfcFlowTerminal: ALDO 9 Surface facade luminaires
In: Default Building
Type - Description: - Lamp LED - Colour 3000K CRI80, 4000K CRI80 - Powder coated aluminium alloy housing - Adjustable aluminium extrusion bracket for ALD-30261, ALD-30262, ALD-30263, ALD-30264,ALD-30265, ALD-30266, ALD-30271, ALD-30272,ALD-30281, ALD-30282, ALD-30291, ALD-30292,ALD-30301, ALD-30302 - Adjustable galvanised steel bracket for ALD-30241, ALD-30242, ALD-30243, ALD-30244,ALD-30251, ALD-30252, ALD-30253, ALD-30254,ALD-30255, ALD-30256 - Two cable entries for through wiring - Clear toughened glass - Remote driver (NOT included) - Bright and consistent distribution, with seamless treatment with continuous mounting - DC24V input, DMX512 address with constant current control for RGBW products; PredefinedType: DIRECTIONSOURCE
Type - Pset_ManufacturerTypeInformation - ArticleNumber: ALD-30801-M-8030; ModelReference: ALDO 9 Surface facade luminaires; Manufacturer: LIGMAN
Type - Pset_LightFixtureTypeCommon - NumberOfSources: 1; TotalWattage: 16.7 W; LightFixtureMountingType: Standing; LightFixturePlacingType: Floor; ManufacturersSpecificInformation: LIGMAN
Material: layer 10 mm
Marketing Information - Emergency lighting possible: no; Product group: ALDO, Surface facade luminaires; Housing color: Not specified
General Information - Weight: 4.5 kg; Case length: 8 cm; Case width: 100 cm; Case height: 14 cm; Uld creation date: 28.10.2025 07:31:56
Pset_ElectricalDeviceCommon - ElectricalDeviceNominalPower: 16.7 W
